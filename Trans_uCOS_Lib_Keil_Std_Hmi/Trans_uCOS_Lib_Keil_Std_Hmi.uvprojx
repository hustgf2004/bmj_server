# Keil uVision project Trans_uCOS_Lib_Keil_Std_Hmi.uvprojx, settings and files
target DebugInExtFlash (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: LPC22xx_uCOS_Lib_Keil
  AfterMake: fromelf --bin .\KeilData\DebugInExtFlash\obj\*.axf --output .\KeilData\DebugInExtFlash\DebugInExtFlash.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __OUT_CHIP
  c misc: -I "C:\Program Files\Keil\ARM\ARMCC\include"
  c include: .\SYS_CODE;.\USER_CODE
  asm define: CTLR
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\SYS_CODE\Scf\InExtFlash.scf
  link misc: --entry start
  group SYS_CODE
    ./SYS_CODE/LPC2200/: Startup.s target.c LPC22xx_uCOS_Lib_Keil.lib
    ./SYS_CODE/SysTools/: sys_tools.c sys_tools.h
    ./SYS_CODE/firmware/: firmware.h
    ./SYS_CODE/AnyPort/: tp.c tpIf.c
    ./SYS_CODE/AnyPort/tpCanDrv/: tpCanDrv.c tpCanDrv.h
    ./SYS_CODE/AnyPort/tpHooks/: tpHooks.c tpHooks.h
  group uCOS-II
    ./SYS_CODE/uCOS-II/: uCOS_II.C OS_CFG.H uCOS_II_add.h
  group ZLG_GUI
    ./SYS_CODE/ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C Font16.c FONT24_32.C GUI_BASIC.C GUI_StockC.C lcddrive.c loadbit.c menu.c windows.c FONT8_16.C
    ./SYS_CODE/ZLG_GUI/OLED_SPD0301/: oled.c
  group DrvLib
    ./SYS_CODE/DrvLib/: Driver2200.c
  group flash
    ./USER_CODE/flash/: IAP.c IAP.h norflash.c norflash.h norflash_Out.c
  group cfg_file
    ./USER_CODE/cfg_file/PinCfg/: LPC2200PinCfg.c LPC2200PinCfg.h
    ./USER_CODE/cfg_file/: config.h
    ./USER_CODE/cfg_file/SysTools/: sys_tools_cfg.h
  group AnyPort/Usr
    ./USER_CODE/AnyPort/: tpCfg.h tpUsr.c tpUsr.h
  group AnyPort/tpKey
    ./USER_CODE/AnyPort/tpPorts/tpKey/: tpKey.c tpKey.h
  group DataStructure/Tree
    ./SYS_CODE/DataStructure/Tree/: Tree.c Tree.h
  group DataStructure/List
    ./SYS_CODE/DataStructure/List/: List.c List.h
  group Menu
    ./USER_CODE/Menu/: afxMenu.c afxMenu.h MenuPage_target.h
  group Menu/01BasicCfg
    ./USER_CODE/Menu/01BasicCfg/: BasicCfg.c BasicCfg.h
    ./USER_CODE/Menu/01BasicCfg/01MinNo/: MinNo.c MinNo.h
    ./USER_CODE/Menu/01BasicCfg/02MaxNo/: MaxNo.c MaxNo.h
    ./USER_CODE/Menu/01BasicCfg/03MasterTime/: MasterTime.c MasterTime.h
    ./USER_CODE/Menu/01BasicCfg/04AddrDir/: AddrDir.c AddrDir.h
    ./USER_CODE/Menu/01BasicCfg/05ShieldNo/: ShieldNo.c ShieldNo.h
    ./USER_CODE/Menu/01BasicCfg/06ServerEn/: ServerEn.c ServerEn.h
    ./USER_CODE/Menu/01BasicCfg/07IrUploadEn/: IrUploadEn.c IrUploadEn.h
    ./USER_CODE/Menu/01BasicCfg/08IrUploadTime/: IrUploadTime.c IrUploadTime.h
    ./USER_CODE/Menu/01BasicCfg/09OpUploadEn/: OpUploadEn.c OpUploadEn.h
    ./USER_CODE/Menu/01BasicCfg/10NetChkTime/: NetChkTime.c NetChkTime.h
    ./USER_CODE/Menu/01BasicCfg/11GateWayEn/: GateWayEn.c GateWayEn.h
    ./USER_CODE/Menu/01BasicCfg/12GateWayDir/: GatewayDir.c GatewayDir.h
    ./USER_CODE/Menu/01BasicCfg/13StartNo/: StartNo.c StartNo.h
    ./USER_CODE/Menu/01BasicCfg/14ScreenSave/: ScreenSave.c ScreenSave.h
    ./USER_CODE/Menu/01BasicCfg/15SnrUploadTime/: SnrUploadTime.c SnrUploadTime.h
    ./USER_CODE/Menu/01BasicCfg/16Lightness/: Lightness.c Lightness.h
    ./USER_CODE/Menu/01BasicCfg/17SwVer/: SwVer.c SwVer.h
  group Menu/02AdvancedCfg
    ./USER_CODE/Menu/02AdvancedCfg/: AdvancedCfg.c AdvancedCfg.h
    ./USER_CODE/Menu/02AdvancedCfg/01PwdAdmin/: PwdAdmin.c PwdAdmin.h
    ./USER_CODE/Menu/02AdvancedCfg/03SwDel/: SwDel.c SwDel.h
  group Menu/33Stop
    ./USER_CODE/Menu/33Stop/: Stop.c Stop.h
  group Menu/34Lock
    ./USER_CODE/Menu/34Lock/: Lock.c Lock.h
  group Menu/35KeyLock
    ./USER_CODE/Menu/35KeyLock/: KeyLock.c KeyLock.h
  group Menu/99PwdInput
    ./USER_CODE/Menu/99PwdInput/: PwdInput.c PwdInput.h
  group USR_CODE
    ./USER_CODE/: ISR.c main.c
    ./USER_CODE/eeprom/: eeprom.c
    ./USER_CODE/tmUart2Can/: tmUart2Can.c tmUart2Can.h
    ./USER_CODE/key/: key.c key.h
target RelInExtFlash (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: as above
  output: LPC22xx_uCOS_Lib_Keil
  AfterMake: fromelf --bin .\KeilData\RelInExtFlash\obj\*.axf --output .\KeilData\RelInExtFlash\RelInExtFlash.bin
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __OUT_CHIP
  c misc: -I "C:\Program Files\Keil\ARM\ARMCC\include"
  c include: .\SYS_CODE;.\USER_CODE
  asm define: CTLR
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\SYS_CODE\Scf\InExtFlash.scf
  link misc: --entry start
